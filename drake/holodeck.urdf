Commit message: tvlqr logs

File: drake/holodeck.urdf (robot description, URDF)
Before this commit: robot holodeck, 1 links, 0 joints
Links:
- link red_hoop_1: geometry collision mesh filename=mesh/hulahoop.obj scale=.001; visual mesh filename=mesh/hulahoop.obj scale=.001
