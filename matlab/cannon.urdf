Commit message: visualizing two robots now!

File: matlab/cannon.urdf (robot description, URDF)
Before this commit: robot cannon, 1 links, 0 joints
Links:
- removed link body
- added link CannonBody, mass .5; visual box size=.5 .5 .5
